CHOICE  EQU 4
ADDIT	EQU 1
SUBTR	EQU 2
MULTI	EQU 3
DIVI    EQU 4
NUM1	EQU 6
NUM2	EQU 2

		AREA mycode,CODE,READONLY
		ENTRY
		EXPORT __main
__main
		MOV R0,#CHOICE
		MOV R1,#NUM1
		MOV R2,#NUM2
		
		CMP R0,#ADDIT
		BEQ ADDITION
		
		CMP R0,#SUBTR
		BEQ SUBTRACTION
		
		CMP R0,#MULTI
		BEQ MULTIPLICATION
		
		CMP R0,#DIVI
		BEQ DIVISION
		
		
ADDITION
		ADD R2,R1,R2
		B STOP


SUBTRACTION		
		SUB R2,R1,R2
		B STOP

MULTIPLICATION
		MUL R2,R1,R2
		B STOP

DIVISION
		UDIV R2,R1,R2
		B STOP
		
STOP  	B STOP
		END
